# Keil uVision project USART.uvprojx, settings and files
target Target_1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0xC000) IROM(0x08000000,0x40000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: USART +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F103xE
  c include: ..\device\delay;..\device\key;..\device\led;..\device\sys;..\device\usart;..\library\STM32F1xx_HAL_Driver\Inc;..\device\system;..\device\sysTick;..\user;..\code;..\device\beep
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group USER
    ./: main.c stm32f1xx_it.c system_stm32f1xx.c
  group device
    ../device/delay/: delay.c
    ../device/key/: key.c
    ../device/led/: led.c
    ../device/sys/: sys.c
    ../device/usart/: usart.c
    ../device/system/: system.c
    ../device/sysTick/: SysTick.c
    ../device/beep/: beep.c
  group code
    ../code/: cmsis_armcc.h cmsis_armclang.h cmsis_compiler.h core_cm3.h startup_stm32f103xe.s
  group stm32_hal
    ../library/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal.c stm32f1xx_hal_cortex.c stm32f1xx_hal_dma.c stm32f1xx_hal_gpio.c stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_uart.c stm32f1xx_hal_usart.c
  group README
    ../: readme.txt
