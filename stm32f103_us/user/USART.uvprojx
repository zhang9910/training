# Keil uVision project USART.uvprojx, settings and files
target Target_1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0xC000) IROM(0x08000000,0x40000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: USART +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F103xE
  c include: ..\device\delay;..\device\key;..\device\led;..\device\sys;..\device\usart;..\library\STM32F1xx_HAL_Driver\Inc;..\device\system;..\device\sysTick;..\user;..\code;..\device\beep;..\RT-Thread\components\finsh;..\RT-Thread\include;..\RT-Thread\include\libc;..\device\task;..\device\timer;..\device\adc;..\device\eeprom;..\device\modbus;..\device;..\device\common;..\device\exti;..\device\chipInfo;..\device\ds18b20
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group USER
    ./: main.c stm32f1xx_it.c system_stm32f1xx.c board.c rtconfig.h dma.c
  group device
    ../device/delay/: delay.c
    ../device/key/: key.c Button.c
    ../device/led/: led.c
    ../device/sys/: sys.c
    ../device/system/: system.c
    ../device/sysTick/: SysTick.c
    ../device/beep/: beep.c
    ../device/task/: Task.c
    ../device/adc/: adc.c adc11.c
    ../device/usart/: usart.c
    ../device/exti/: exti.c
    ../device/chipInfo/: ChipInfo.c
    ../device/timer/: BspTimer.c
    ../device/ds18b20/: BspDs18b20.c
  group code
    ../code/: cmsis_armcc.h cmsis_armclang.h cmsis_compiler.h core_cm3.h startup_stm32f103xe.s
  group RT-Thread/Kernel
    ../RT-Thread/src/: clock.c components.c cpu.c idle.c ipc.c irq.c kservice.c mem.c memheap.c mempool.c object.c scheduler.c slab.c thread.c timer.c
  group RT-Thread/Ports
    ../RT-Thread/libcpu/arm/cortex-m3/: cpuport.c context_rvds.S
  group RT-Thread/Finish
    ../RT-Thread/components/finsh/: cmd.c msh.c shell.c
  group stm32_hal
    ../library/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal.c stm32f1xx_hal_adc.c stm32f1xx_hal_adc_ex.c stm32f1xx_hal_cortex.c stm32f1xx_hal_dma.c stm32f1xx_hal_gpio.c stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_uart.c stm32f1xx_hal_usart.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_exti.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c
  group README
    ../: readme.txt
